# Keil uVision project tuwan3gA.uvprojx, settings and files
target tuwan3g (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: tuwan3g
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,USE_STM32F4_DISCO,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CH
  c misc: --C99
  c include: ../Inc;                                                                             ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                             ../Drivers/CMSIS/Include;                                                                             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group forth
    ../Src/Forth/: ForthDecode.c ForthTeminal.c ForthWords.c
  group Application/User
    ../Src/: freertos.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c flash.c I2S.c snore.c tuwan.c libPDMFilter_Keil.lib InputOutput.c W25Q16.c position.c ActionTask.c Qstruct.c SnoreTask.c SpiFlashFileSys.c imageJump.c bluetooth.c Airsensor.lib
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c timers.c list.c tasks.c queue.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/DSP
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.1.0
